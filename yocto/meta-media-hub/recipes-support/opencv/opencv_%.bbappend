PACKAGECONFIG:pn-opencv = "python3 gstreamer ffmpeg"

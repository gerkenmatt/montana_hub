COMPATIBLE_MACHINE = ".*"
